# Keil uVision project nxpCar.uvprojx, settings and files
target Target 1 (5060020::V5.06 (build 20)::ARMCC)
  device: SKEAZ128xxx4 NXP
  pack: Keil.Kinetis_KEAxx_DFP.1.3.0
  cpu: IROM(0x00000000,0x00020000) IRAM(0x1FFFF000,0x00004000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: nxpCar
  c flags: Optim=1 OneElfS=1 uC99=1 wLevel=2
  c include: .\user\inc;.\lib\inc;.\drives\inc
  memory RVCT4: ROM 0x0 size 0x20000
  memory RVCT9: RAM 0x1ffff000 size 0x4000
  group user
    ./user/src/: nxpCar.c
  group lib
    ./drives/src/: KEA128_uart.c common.c misc.c KEA128_port.c
software components: CMSIS:CORE 4.1.0, CMSIS:DSP 1.4.5, Device:Startup 1.0.0
